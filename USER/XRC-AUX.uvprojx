# Keil uVision project XRC-AUX.uvprojx, settings and files
target XRC-AUX (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: XRC-AUX +hex
  c flags: Optim=1 oTime=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\GPIO;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\MAVLink;..\MAVLink\common;..\HARDWARE\LCD;..\HARDWARE\USART3;..\HARDWARE\TIMER;..\USBLib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ./: xuan.h common.h lcdfont.h bkg.h main.c input.c sbus.c crsf.c ppm.c channel.c output.c Xui.c usb.c desk.c data.c tool.c setup.c mixer.c logic.c system.c triangle.c model.c mavlink.c hud.c hud2.c
  group HARDWARE
    ../HARDWARE/USART3/: usart3.c
    ./: spi.c dma.c stmflash.c adc.c ips.c pwm.c mpu6050.c
    ../HARDWARE/TIMER/: timer.c
    ../SYSTEM/delay/: delay.c
    ../HARDWARE/GPIO/: gpio.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ./: stm32f10x_it.c system_stm32f10x.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_rcc.c
  group MAVLINK
    ../MAVLink/: open_tel_mavlink.c mavlink_usart_fifo.c checksum.h mavlink_conversions.h mavlink_helpers.h mavlink_types.h protocol.h mavlink_avoid_errors.h
    ../MAVLink/common/: common.h mavlink.h mavlink_msg_attitude.h mavlink_msg_attitude_quaternion.h mavlink_msg_attitude_setpoint_external.h mavlink_msg_auth_key.h mavlink_msg_battery_status.h mavlink_msg_change_operator_control.h mavlink_msg_change_operator_control_ack.h mavlink_msg_command_ack.h mavlink_msg_command_long.h mavlink_msg_data_stream.h mavlink_msg_data_transmission_handshake.h mavlink_msg_debug.h mavlink_msg_debug_vect.h mavlink_msg_distance_sensor.h mavlink_msg_encapsulated_data.h mavlink_msg_global_position_int.h mavlink_msg_global_position_setpoint_external_int.h mavlink_msg_global_position_setpoint_int.h mavlink_msg_global_vision_position_estimate.h mavlink_msg_gps_global_origin.h mavlink_msg_gps_inject_data.h mavlink_msg_gps_raw_int.h mavlink_msg_gps_rtk.h mavlink_msg_gps_status.h mavlink_msg_gps2_raw.h mavlink_msg_gps2_rtk.h mavlink_msg_heartbeat.h mavlink_msg_highres_imu.h mavlink_msg_hil_controls.h mavlink_msg_hil_gps.h mavlink_msg_hil_optical_flow.h mavlink_msg_hil_rc_inputs_raw.h mavlink_msg_hil_sensor.h mavlink_msg_hil_state.h mavlink_msg_hil_state_quaternion.h mavlink_msg_local_ned_position_setpoint_external.h mavlink_msg_local_position_ned.h mavlink_msg_local_position_ned_system_global_offset.h mavlink_msg_local_position_setpoint.h mavlink_msg_log_data.h mavlink_msg_log_entry.h mavlink_msg_log_erase.h mavlink_msg_log_request_data.h mavlink_msg_log_request_end.h mavlink_msg_log_request_list.h mavlink_msg_manual_control.h mavlink_msg_manual_setpoint.h mavlink_msg_memory_vect.h mavlink_msg_mission_ack.h mavlink_msg_mission_clear_all.h mavlink_msg_mission_count.h mavlink_msg_mission_current.h mavlink_msg_mission_item.h mavlink_msg_mission_item_reached.h mavlink_msg_mission_request.h mavlink_msg_mission_request_list.h mavlink_msg_mission_request_partial_list.h mavlink_msg_mission_set_current.h mavlink_msg_mission_write_partial_list.h mavlink_msg_named_value_float.h mavlink_msg_named_value_int.h mavlink_msg_nav_controller_output.h mavlink_msg_omnidirectional_flow.h mavlink_msg_optical_flow.h mavlink_msg_param_request_list.h mavlink_msg_param_request_read.h mavlink_msg_param_set.h mavlink_msg_param_value.h mavlink_msg_ping.h mavlink_msg_power_status.h mavlink_msg_radio_status.h mavlink_msg_raw_imu.h mavlink_msg_raw_pressure.h mavlink_msg_rc_channels.h mavlink_msg_rc_channels_override.h mavlink_msg_rc_channels_raw.h mavlink_msg_rc_channels_scaled.h mavlink_msg_request_data_stream.h mavlink_msg_roll_pitch_yaw_rates_thrust_setpoint.h mavlink_msg_roll_pitch_yaw_speed_thrust_setpoint.h mavlink_msg_roll_pitch_yaw_thrust_setpoint.h mavlink_msg_safety_allowed_area.h mavlink_msg_safety_set_allowed_area.h mavlink_msg_scaled_imu.h mavlink_msg_scaled_imu2.h mavlink_msg_scaled_pressure.h mavlink_msg_serial_control.h mavlink_msg_servo_output_raw.h mavlink_msg_set_global_position_setpoint_int.h mavlink_msg_set_gps_global_origin.h mavlink_msg_set_local_position_setpoint.h mavlink_msg_set_mode.h mavlink_msg_set_quad_motors_setpoint.h mavlink_msg_set_quad_swarm_led_roll_pitch_yaw_thrust.h mavlink_msg_set_quad_swarm_roll_pitch_yaw_thrust.h mavlink_msg_set_roll_pitch_yaw_thrust.h mavlink_msg_setpoint_6dof.h mavlink_msg_setpoint_8dof.h mavlink_msg_sim_state.h mavlink_msg_state_correction.h mavlink_msg_statustext.h mavlink_msg_sys_status.h mavlink_msg_system_time.h mavlink_msg_terrain_check.h mavlink_msg_terrain_data.h mavlink_msg_terrain_report.h mavlink_msg_terrain_request.h mavlink_msg_vfr_hud.h mavlink_msg_vicon_position_estimate.h mavlink_msg_vision_position_estimate.h mavlink_msg_vision_speed_estimate.h testsuite.h version.h
  group USB
    ../USBLib/src/: usb_hw.c usbcore.c usbdesc.c usbuser.c
